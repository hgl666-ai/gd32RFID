# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.3.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32E230,USE_STDPERIPH_DRIVER
  c include: D:\Develop\Keil_MDK\ARM\PACK\ARM\CMSIS\5.7.0\CMSIS\Include;.\Head
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Start
    ./Start/: startup_gd32e23x.s
  group Library
    ./Library/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c system_gd32e23x.c
  group Head
    ./Head/: gd32e23x.h gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_it.h gd32e23x_libopt.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h main.h system_gd32e23x.h bsp_systick.h bsp_usart.h bsp_i2c.h bsp_fm17622.h protocol.h app_protocol.h bsp_uid.h bsp_flash.h bsp_crypto.h bsp_watchdog.h des.h fmse_port.h fmse_i2c.h se_cmd.h
  group User
    ./User/: gd32e23x_it.c main.c
  group Bsp
    ./Bsp/: bsp_systick.c bsp_i2c.c bsp_fm17622.c protocol.c app_protocol.c bsp_flash.c bsp_usart.c bsp_uid.c bsp_crypto.c bsp_watchdog.c des.c fmse_port.c fmse_i2c.c se_cmd.c
software components: CMSIS:CORE 5.4.0
